# Keil uVision project tester_f373.uvprojx, settings and files
target tester_f373 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F373RCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(72000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: tester_f373 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F373xC
  c include: ../Core/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include;..\Core\Src\board;..\Core\Src\task;..\..\G0_COMMON\app_timer;..\..\G0_COMMON\cmd_consumer;..\..\G0_COMMON\xUartDev;..\..\G0_COMMON\xRingBuffer;..\..\G0_COMMON\gpio_input;..\..\G0_COMMON\gpio_output;..\..\G0_COMMON\xIIC_IO;..\..\G0_COMMON\xCRC16;..\..\G0_COMMON\xMisc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32f373xc.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_usb.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group usr/board
    ../Core/Src/board/: board.c
  group usr/task
    ../Core/Src/task/: led_flash.c task.c
  group usr/app_timer
    ../../G0_COMMON/app_timer/: app_timer.c
  group usr/cmd_consumer
    ../../G0_COMMON/cmd_consumer/: cmd_consumer.c
  group usr/uart_dev
    ../../G0_COMMON/xUartDev/: uartDev.c
  group usr/ringbuff
    ../../G0_COMMON/xRingBuffer/: ring_buffer.c
  group usr/gpio
    ../../G0_COMMON/gpio_input/: input.c inputCmd.c
    ../../G0_COMMON/gpio_output/: output.c outputCmd.c
  group usr/iic_io
    ../../G0_COMMON/xIIC_IO/: IIC_IO.c
  group usr/crc16
    ../../G0_COMMON/xCRC16/: crc16.c
  group usr/misc
    ../../G0_COMMON/xMisc/: gpioDecal.c misc.c
software components: CMSIS:CORE 4.3.0
